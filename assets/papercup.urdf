Commit message: コップからはみ出す問題は解決？

File: assets/papercup.urdf (robot description, URDF)
Before this commit: robot paper_cup, 1 links, 0 joints
Links:
- link base_link: geometry collision box size=0.002 0.025 0.030; collision box size=0.002 0.025 0.030
